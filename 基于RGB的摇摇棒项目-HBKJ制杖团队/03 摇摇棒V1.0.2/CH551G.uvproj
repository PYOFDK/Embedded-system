# Keil uVision project CH551G.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: CH551G +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\GPIO
  group App
    ./: main.c
